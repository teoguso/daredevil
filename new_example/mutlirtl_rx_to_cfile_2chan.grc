<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>mutlirtl_rx_to_cfile_2chan</value></param>
<param><key>author</key><value>Piotr Krysik</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>description</key><value>Sample application for recording to binary files the samples from inputs of two channel multi-rtl receiver</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
<param><key>title</key><value>Two channel multi-rtl RX to cfile</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch0_id_string</value></param>
<param><key>label</key><value>ch0-id-string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"0"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ch1_id_string</value></param>
<param><key>label</key><value>ch1-id-string</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"1"</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_ch0</value></param>
<param><key>file</key><value>fname_ch0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>file_sink_ch1</value></param>
<param><key>file</key><value>fname_ch1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fname_ch0</value></param>
<param><key>label</key><value>fname-ch0</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ch0.cfile</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fname_ch1</value></param>
<param><key>label</key><value>fname-ch1</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>ch1.cfile</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_ch0</value></param>
<param><key>label</key><value>freq-ch0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>88.8e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_ch1</value></param>
<param><key>label</key><value>freq_ch1</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>88.8e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>freq_corr</value></param>
<param><key>label</key><value>freq-corr</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_ch0</value></param>
<param><key>label</key><value>gain-ch0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain_ch1</value></param>
<param><key>label</key><value>gain-ch1</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>head_ch0</value></param>
<param><key>num_items</key><value>nsamples</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>head_ch1</value></param>
<param><key>num_items</key><value>nsamples</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>multi_rtl_source</key>
<param><key>id</key><value>multi_rtl_source</value></param>
<param><key>freq0</key><value>freq_ch0</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>id_string0</key><value>ch0_id_string</value></param>
<param><key>gain0</key><value>gain_ch0</value></param>
<param><key>sync_gain0</key><value>sync_gain_ch0</value></param>
<param><key>freq1</key><value>freq_ch1</value></param>
<param><key>gain_mode1</key><value>False</value></param>
<param><key>id_string1</key><value>ch1_id_string</value></param>
<param><key>gain1</key><value>gain_ch1</value></param>
<param><key>sync_gain1</key><value>sync_gain_ch1</value></param>
<param><key>corr</key><value>freq_corr</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>sync_freq</key><value>sync_freq</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>nsamples</value></param>
<param><key>label</key><value>nsamples</value></param>
<param><key>short_id</key><value>N</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0_0</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>interp</key><value>1</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>label</key><value>samp-rate</value></param>
<param><key>short_id</key><value>r</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_freq</value></param>
<param><key>label</key><value>sync-freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>88.8e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_gain_ch0</value></param>
<param><key>label</key><value>sync-gain-ch0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sync_gain_ch1</value></param>
<param><key>label</key><value>sync-gain-ch1</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>30</value></param>
</block>
<connection><source_block_id>head_ch0</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>head_ch1</source_block_id><sink_block_id>rational_resampler_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multi_rtl_source</source_block_id><sink_block_id>head_ch0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>multi_rtl_source</source_block_id><sink_block_id>head_ch1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>file_sink_ch0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0_0</source_block_id><sink_block_id>file_sink_ch1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
